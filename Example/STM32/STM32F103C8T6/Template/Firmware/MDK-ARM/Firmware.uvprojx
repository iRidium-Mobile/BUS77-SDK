# Keil uVision project Firmware.uvprojx, settings and files
target Firmware (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Firmware +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: ..\..\..\..\..\..\Utility\FirmwareEncode.exe --in=$P@L.bin --out=$P@L.ifw --key=000102030405060708090a0b0c0d0e0ff0e0d0c0b0a09080706050403020100000000000000000000000000000000000
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\Common;..\..\..\..\..\..\iRidiumProtocol;..\..\..\..\..\..\iRidiumProtocol\Crypto;..\iRidiumDevice
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group iRidiumProtocol
    ../../../../../../iRidiumProtocol/: CInBuffer.cpp CInBuffer.h CIridiumBusInBuffer.cpp CIridiumBusInBuffer.h CIridiumBusOutBuffer.cpp CIridiumBusOutBuffer.h CIridiumBusProtocol.cpp CIridiumBusProtocol.h CIridiumInBuffer.cpp CIridiumInBuffer.h CIridiumOutBuffer.cpp CIridiumOutBuffer.h CIridiumProtocol.cpp CIridiumProtocol.h COutBuffer.cpp COutBuffer.h Iridium.cpp Iridium.h IridiumBus.h IridiumCRC16.cpp IridiumCRC16.h IridiumPlatform.h IridiumTime.h IridiumTypes.h IridiumValue.h IridiumBytes.cpp IridiumBytes.h
  group iRidiumProtocol/Crypto
    ../../../../../../iRidiumProtocol/Crypto/: CIridiumCipher.h CIridiumCipherGrasshopper.cpp CIridiumCipherGrasshopper.h CIridiumStreebog.cpp CIridiumStreebog.h
  group iRidiumDevice
    ../iRidiumDevice/: CDevice.cpp CDevice.h IridiumConfig.h
  group Common
    ../../../Common/: CCanPort.cpp CCanPort.h EEPROM.cpp EEPROM.h Flash.cpp Flash.h MemoryMap.h UTF8.cpp UTF8.h
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
