# Keil uVision project Firmware.uvprojx, settings and files
target Firmware (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L452CCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Firmware +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: ..\..\..\..\..\..\..\Utility\FirmwareEncode.exe --in=$P@L.bin --out=$P@L.ifw --key=000102030405060708090a0b0c0d0e0ff0e0d0c0b0a09080706050403020100000000000000000000000000000000000
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L452xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\iRidiumDevice;..\..\DeviceCommon;..\..\..\..\ChipCommon;..\..\..\..\..\MCUCommon;..\..\..\..\..\..\Common;..\..\..\..\..\..\..\iRidiumProtocol;..\..\..\..\..\..\..\iRidiumProtocol\Crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application/MDK-ARM
    ./: startup_stm32l452xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_can.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Common
    ../../../../../../Common/: CCanPort.cpp CCanPort.h CFirmware.cpp CFirmware.h CIndicator.cpp CIndicator.h UTF8.cpp UTF8.h NVRAMCommon.h UnixTime.cpp UnixTime.h
  group MCUCommon
    ../../../../../MCUCommon/: CAbstractNVRAM.cpp CAbstractNVRAM.h CFlashNVRAM.cpp CFlashNVRAM.h
  group ChipCommon
    ../../../../ChipCommon/: CommonCAN.cpp CommonCAN.h Flash.cpp Flash.h CI2CNVRAM.cpp CI2CNVRAM.h CI2CNVRAM8Bit.cpp CI2CNVRAM8Bit.h CI2CNVRAM16Bit.cpp CI2CNVRAM16Bit.h
  group DeviceCommon
    ../../DeviceCommon/: InputOutput.cpp InputOutput.h CDeviceIndicator.cpp CDeviceIndicator.h DeviceDefine.h FLASHMemoryMap.h
  group iRidiumDevice
    ../iRidiumDevice/: CDevice.cpp CDevice.h IridiumConfig.h
  group iRidiumProtocol
    ../../../../../../../iRidiumProtocol/: CInBuffer.cpp CInBuffer.h CIridiumBusInBuffer.cpp CIridiumBusInBuffer.h CIridiumBusOutBuffer.cpp CIridiumBusOutBuffer.h CIridiumBusProtocol.cpp CIridiumBusProtocol.h CIridiumInBuffer.cpp CIridiumInBuffer.h CIridiumOutBuffer.cpp CIridiumOutBuffer.h CIridiumProtocol.cpp CIridiumProtocol.h COutBuffer.cpp COutBuffer.h Iridium.cpp Iridium.h IridiumBus.h IridiumBytes.cpp IridiumBytes.h IridiumChannels.h IridiumCRC16.cpp IridiumCRC16.h IridiumPlatform.h IridiumTime.h IridiumTypes.h IridiumUnits.h IridiumValue.h
  group iRidiumProtocol/Crypto
    ../../../../../../../iRidiumProtocol/Crypto/: CIridiumCipher.h CIridiumCipherGrasshopper.cpp CIridiumCipherGrasshopper.h CIridiumStreebog.cpp CIridiumStreebog.h
software components: CMSIS:CORE 4.3.0
